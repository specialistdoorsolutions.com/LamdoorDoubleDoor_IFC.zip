Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2023-02-21T07:02:08
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20220517_1515(x64) - Exporter 20.3.2.0 - Alternate UI 20.3.2.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Feb 21 07:02:08 2023 * Host: BIMServices * Database: C:\Users\PIOTRB~1\AppData\Local\Temp\40b0be75-b3bf-485f-8e57-0e4599fcc296\eafde10b-5110-4686-ab61-ff5329a45f23\ifc * Database version: 5507 * Database creation date: Tue Feb 21 07:02:08 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Feb 21 07:02:08 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Feb 21 07:02:08 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject
COBie - Category: Project Information

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
COBie - Category: Project Information

# IfcBuilding
COBie - Category: Project Information

# IfcBuildingStorey: Level:Level 1, Level 1
LongName: Level 1; Elevation: 0 mm
COBie - Category: Levels; Name: Level 1

# IfcDoor: NBS_SpecialistDoorSolutions_CompDrsts_Lamdoor_DoubleLeafDoor_VPA9:SingleSwing, NBS_SpecialistDoorSolutions_CompDrsts_Lamdoor_DoubleLeafDoor_VPA9:SingleSwing:311337
In: Level 1
Type - OperationType: DOUBLE_DOOR_SINGLE_SWING; ConstructionType: WOOD; ParameterTakesPrecedence: no; Sizeable: no; Material: NBS_SpecialistDoorSolutions_StainlessSteel, NBS_SpecialistDoorSolutions_TexturedFinish_LupinLRV23, NBS_ClearanceZone, NBS_Glass_Single, NBS_SpecialistDoorSolutions_Woodgrains_AmericanWhiteOakLRV43
Type - NBS_SpecialistDoorSolutions_CompDrsts_Lamdoor_DoubleLeafDoor_VPA9:SingleSwing:311337:1 - PanelOperation: SWINGING
Type - BOS_General - Author: NBS; BIMObjectName: NBS_SpecialistDoorSolutions_WoodDoorsets_LamdoorDoubleDoor_VPA9_SingleSwing; ManufacturerName: Specialist Door Solutions; ManufacturerURL: specialistdoorsolutions.com; ProductInformation: https://specialistdoorsolutions.com/products/doorsets/sds-lamdoor/; Uniclass2015Title: Wood doorsets; Uniclass2015Code: Pr_30_59_24_97; Uniclass2015Version: Products v1.28; Version: 1
Type - NBS_Data - Accessories: Overhead Panels, Sidescreen Panels, Not required; AcousticPerformance: 0–20 dB, 21–32 dB, 33–35 dB; ArchitravesColourExternal: Snowflake RAL 9003, Gunpowder RAL 7035, Flint RAL 7037, Lupin RAL 5024, Jade, American White Oak, Ellmau Beech; ArchitravesColourInternal: Snowflake RAL 9003, Gunpowder RAL 7035, Flint RAL 7037, Lupin RAL 5024, Jade, American White Oak, Ellmau Beech; ArchitravesFinish: PVC; ArchitravesMaterial: Medium density fibreboard, PVC; BeadingMaterial: Timber, lacquered, Timber, primed; BeadingType: Timber bead; Configuration: Double-leaf, single-action, Double-leaf, double-action; ContainsRedListMaterials: Yes; CountryOfProductManufacture: United Kingdom; DoorAccessories: Lock profile options, Intumescent jackets, Fire signage, Door closers, EMHO door closers, Hinges, Kickplates, Edge protectors, Fire and smoke seals, Threshold seals, Door handings, Overhead panels, Sidescreen panels, Air transfer grilles; DoorLeafColourExternal: As Frame, Snowflake RAL 9003, Gunpowder RAL 7035, Flint RAL 7037, Lupin RAL 5024, Jade, American White Oak, Ellmau Beech; DoorLeafColourInternal: As External, Snowflake RAL 9003, Gunpowder RAL 7035, Flint RAL 7037, Lupin RAL 5024, Jade, American White Oak, Ellmau Beech; DoorLeafCore: Timber particulate board; DoorLeafFinish: PVC; DoorLeafThickness: 47 mm, 57 mm; DoorsetSize: Bespoke; Edges: Postformed; FormaldehydeEmissions: To BS EN 13986, E1; FrameColour: Snowflake RAL 9003, Gunpowder RAL 7035, Flint RAL 7037, Lupin RAL 5024, Jade, American White Oak, Ellmau Beech; FrameFinish: PVC postformed; FrameMaterial: Hardwood, Softwood; FramePerimeterSealsOrInserts: Intumescent seal, Intumescent brush; FrameThreshold: Up to 10 mm; FrameTypeOptions: Traditional frame, Split frame, Double swing centre; GlazingType: Clearglaze, Frostglaze; HandleType: Pull handle and push plate, Cylinder pull, Digi lock; IntruderResistanceApplication: Hinge side only; Ironmongery: Define range - Stainless steel, Define plus range - Anti-microbial, Define copper range - Copper nickel; ReactionToFire: NFR, FD30, FD30s, FD60, FD60s; Standard: To BS 476-22 and BS EN 1634-1; StrengthAndDurability: Medium Duty; ThirdPartyCertification: ISO 9001:2015 ISO 114001:2015 FSC, BM Trada Q-Mark; VisionPanel: VPA9
Type - IFC - IfcExportAs: IfcDoorType; IfcExportType: DOOR
Type - COBie - NominalHeight: 0 mm; NominalLength: 0 mm; NominalWidth: 0 mm; AccessibilityPerformance: n/a; AssetType: Fixed; Category: Pr_30_59_24_97:Wood doorsets; CodePerformance: n/a; Color: Blue, White, Yellow, Green, Grey; Constituents: n/a; Description: PVC postformed doorset; DurationUnit: year; ExpectedLife: n/a; Features: n/a; Finish: Textured; Grade: n/a; Manufacturer: Russell@specialistdoorsolutions.com; Material: Wood, Glass, Steel, PVC, Timber; ModelNumber: n/a; ModelReference: LamdoorDoubleDoor_VPA9_SingleSwing; Name: WoodDoorsets_LamdoorDoubleDoor_VPA9_SingleSwing_SpecialistDoorSolutions; ReplacementCost: n/a; Shape: Rectangle; Size: n/a; SustainabilityPerformance: All timber products certified FSC 100% full chain of custody,; WarrantyDescription: Two year; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
OverallHeight: 2124 mm; OverallWidth: 1648 mm; Material: NBS_Glass_Single, NBS_SpecialistDoorSolutions_Woodgrains_AmericanWhiteOakLRV43, NBS_SpecialistDoorSolutions_StainlessSteel, NBS_SpecialistDoorSolutions_TexturedFinish_LupinLRV23
COBie - AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59
